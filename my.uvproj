# Keil uVision project my.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: AT91SAM7S256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(20000000) CPUTYPE(ARM7TDMI)
  output: my +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  group Source Group 1
    ./: SAM7.s main.c mypwm.c myusart.c mytwi_new.c mypit.c timer.c LED.c spibaro.c gps.c attitude.c IMU.c inout.c PosEst.c compass_on_gps.c EEPROM.c fixed_matrix_control.c ADC.c test_cpp.cpp SDcard.c twi_fast.c Filter.c USB.c
